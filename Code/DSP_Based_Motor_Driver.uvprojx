# Keil uVision project DSP_Based_Motor_Driver.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: DSP_Based_Motor_Driver
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Main
    ./: main.s Handle_KeyPad.s Handle_Switches.s Handle_ADC0SS3_DSP.s Startup.s OutChar.s Update_Flags.s PrintKey.s Debounce_K.s Debounce_SW.s SPI3_WriteByte.s ScreenMemory.s zxpix_font.h Font6x8.s Update_Screen.s Update_LED_Status.s Set_LED_Status.s Input_Thresh.s Update_Thresh_Screen.s
  group ISRs
    ./: ADC0Seq0_Handler.s ADC0Seq3_Handler.s SysTick_Handler.s Timer0A_Handler.s
  group Inits
    ./: Init_GPIO_A.s Init_GPIO_B.s Init_GPIO_D.s Init_GPIO_E.s Init_GPIO_F.s Init_SRAM.s Init_TIMER0.s Init_SysTick.s Init_SPI3.s Init_ADC0.s Init_Nokia5110.s
  group Print
    ./Print/: Convert_ADCData.s DigitExtractor.s Divide.s OutStr.s Print_ADC0SS3Data.s
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
